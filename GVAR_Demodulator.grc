options:
  parameters:
    author: Aang23
    generate_options: qt_gui
    id: gvar_demod
    output_language: python
    title: GVAR Demodulator
  states: {}

blocks:
- name: clock_alpha
  id: variable_qtgui_range
  parameters:
    label: Clock Alpha
    min_len: '150'
    orient: Qt.Horizontal
    start: '1e-3'
    step: '1e-5'
    stop: '10e-3'
    value: '8.7e-3'
  states: {}
- name: pll_alpha
  id: variable_qtgui_range
  parameters:
    label: PLL Alpha
    min_len: '150'
    orient: Qt.Horizontal
    start: '0.00100'
    step: '0.00001'
    stop: '0.10000'
    value: '0.00200'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 6e6
  states: {}
- name: sps
  id: variable
  parameters:
    value: (samp_rate*1.0)/(symbol_rate*1.0)
  states: {}
- name: symbol_rate
  id: variable
  parameters:
    value: 2.111e6
  states: {}
- name: analog_agc_xx_0_0
  id: analog_agc_xx
  parameters:
    gain: 0.5/32768.0
    max_gain: '4000'
    rate: '0.0010e-3'
    reference: '1'
    type: complex
  states: {}
- name: blocks_complex_to_real_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    type: byte
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    repeat: 'False'
    type: short
  states: {}
- name: blocks_interleaved_short_to_complex_0
  id: blocks_interleaved_short_to_complex
  parameters:
    vector_input: 'False'
  states: {}
- name: blocks_throttle_0_0_1_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate*10
    type: complex
  states: {state: bypassed}
- name: blocks_unpacked_to_packed_xx_0
  id: blocks_unpacked_to_packed_xx
  parameters:
    bits_per_chunk: '1'
    endianness: gr.GR_MSB_FIRST
    type: byte
  states: {}
- name: digital_binary_slicer_fb_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: digital_clock_recovery_mm_xx_0
  id: digital_clock_recovery_mm_xx
  parameters:
    gain_mu: clock_alpha
    gain_omega: clock_alpha**2/4.0
    mu: '0.5'
    omega: sps
    omega_relative_limit: '0.005'
    type: complex
  states: {}
- name: digital_costas_loop_cc_0
  id: digital_costas_loop_cc
  parameters:
    order: '2'
    w: pll_alpha
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    color1: '"dark red"'
    grid: 'True'
    label1: Constellation diagram
    marker1: '1'
    name: MetOp
    size: '1024'
    type: complex
    update_time: '0.05'
    xmax: '1'
    xmin: '-1'
    ymax: '1'
    ymin: '-1'
  states: {}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    average: '0.05'
    bw: samp_rate
    fc: '0'
    fftsize: '8192'
    grid: 'True'
    type: complex
    update_time: '0.05'
    wintype: firdes.WIN_BLACKMAN_hARRIS
    ymax: '-40'
    ymin: '-60'
  states: {}
- name: root_raised_cosine_filter_0
  id: root_raised_cosine_filter
  parameters:
    alpha: '0.7'
    decim: '1'
    gain: '1'
    ntaps: '361'
    samp_rate: samp_rate
    sym_rate: symbol_rate
    type: fir_filter_ccf
  states: {}
- name: virtual_sink_0_0
  id: virtual_sink
  parameters:
    stream_id: bb_input
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: bb_input
  states: {}

connections:
- [analog_agc_xx_0_0, '0', qtgui_freq_sink_x_1, '0']
- [analog_agc_xx_0_0, '0', root_raised_cosine_filter_0, '0']
- [blocks_complex_to_real_0, '0', digital_binary_slicer_fb_0, '0']
- [blocks_file_source_0, '0', blocks_interleaved_short_to_complex_0, '0']
- [blocks_interleaved_short_to_complex_0, '0', blocks_throttle_0_0_1_0, '0']
- [blocks_throttle_0_0_1_0, '0', virtual_sink_0_0, '0']
- [blocks_unpacked_to_packed_xx_0, '0', blocks_file_sink_0, '0']
- [digital_binary_slicer_fb_0, '0', blocks_unpacked_to_packed_xx_0, '0']
- [digital_clock_recovery_mm_xx_0, '0', blocks_complex_to_real_0, '0']
- [digital_clock_recovery_mm_xx_0, '0', qtgui_const_sink_x_0, '0']
- [digital_costas_loop_cc_0, '0', digital_clock_recovery_mm_xx_0, '0']
- [root_raised_cosine_filter_0, '0', digital_costas_loop_cc_0, '0']
- [virtual_source_0, '0', analog_agc_xx_0_0, '0']

metadata:
  file_format: 1
